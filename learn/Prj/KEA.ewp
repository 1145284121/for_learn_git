# IAR project KEA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TRK_KEA128; CPU_KEA128; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\App\inc; ..\Broad\inc; ..\Chip\inc; ..\Lib\inc; ..\User\inc; E:\各种资料\智能车\电磁三轮\电磁三轮程序\电磁三轮程序+电路+机械图 速度2.7m\第十三届电磁组程序 - 无调参系统版\Chip\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA.srec
  ILINK.IlinkOutputFile: KEA.out
  ILINK.IlinkIcfFile: config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/inc
    ../App/inc/: common.h gpio_icf.h includefile.h isr.h KEA128_port_cfg.h misc.h
    ../../../../KEA128四元数解算/User/inc/: System_UI.h
  group App/src
    ../App/src/: common.c isr.c main.c misc.c
    ../../../../KEA128四元数解算/User/src/: System_UI.c
  group Chip/inc
    ../Chip/inc/: KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_irq.h KEA128_kbi.h KEA128_port.h KEA128_systick.h KEA128_uart.h
    ../../../../第十三届电磁组程序 -/Lib/Drivers/inc/: SoftIIC.h
  group Chip/src
    ../App/src/: BMX055.c
    ../Chip/src/: KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_systick.c KEA128_uart.c
    ../../../../第十三届电磁组程序 -/Lib/Drivers/src/: SoftIIC.c
  group Lib
    ../Lib/: startup_SKEAZ1284.s
  group Lib/inc
    ../Lib/inc/: core_cm0plus.h SKEAZ1284.h system_SKEAZ1284.h
    $EW_DIR$/arm/inc/c/: math.h
  group Lib/src
    ../Lib/src/: system_SKEAZ1284.c
  group User/inc
    ../User/inc/: bsp_global_var.h bsp_my_oled.h bsp_oled.h car_init.h direction.h flash_param.h ir.h scope.h speed.h ui_debug.h ui_debug_common.h ui_setpage.h
  group User/src
    ../User/src/: Attitude_Calculation.c bsp_global_var.c bsp_my_oled.c bsp_oled.c car_init.c direction.c flash_param.c ir.c scope.c speed.c ui_debug.c ui_debug_common.c ui_setpage.c
